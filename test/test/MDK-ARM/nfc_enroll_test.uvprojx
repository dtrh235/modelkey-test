# Keil uVision project nfc_enroll_test.uvprojx, settings and files
target stm32f407vet6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nfc_enroll_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_RS485_ENABLE=1
  c misc: --locale=english --preinclude=..\User\test_preinclude.h
  c include: ..\User;..\..\..\Host\Drivers;..\..\..\Host\Drivers\CMSIS\Include;..\..\..\Host\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Host\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Host\Drivers\BSP\mfrc522;..\..\..\Host\Drivers\BSP\W25Q16;..\..\..\Host\Drivers\BSP\TOUCH;..\..\..\Host\Drivers\BSP\LCD;..\..\..\Host\Drivers\BSP\24CXX;..\..\..\Host\Drivers\SYSTEM\sys;..\..\..\Host\Drivers\SYSTEM\delay;..\..\..\Host\Drivers\SYSTEM\usart;..\..\..\Host\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../Host/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Test/User
    ../User/: test_main.c test_rs485_log.c test_hal_msp.c stm32f4xx_it.c test_touch_diag.c test_unlock_diag.c test_stubs.c
    ../../../Host/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../Host/User/: stm32f4xx_hal_conf.h
  group Host/User
    ../../../Host/User/: app_nfc_hw.c app_rs485_link.c app_ccm_ram.c user_auth_portable.c
  group Drivers/BSP/Touch
    ../../../Host/Drivers/BSP/TOUCH/: ctiic.c ft5206.c touch.c
  group Drivers/BSP/W25Q
    ../../../Host/Drivers/BSP/W25Q16/: bsp_w25q16.c
  group Drivers/BSP/NFC
    ../../../Host/Drivers/BSP/mfrc522/: door.c MFRC522.c
  group Drivers/SYSTEM
    ../../../Host/Drivers/SYSTEM/sys/: sys.c
    ../../../Host/Drivers/SYSTEM/delay/: delay.c
  group Drivers/HAL
    ../../../Host/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
