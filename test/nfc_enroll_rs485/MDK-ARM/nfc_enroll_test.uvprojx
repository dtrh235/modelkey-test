# Keil uVision project nfc_enroll_test.uvprojx, settings and files
target stm32f407vet6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nfc_enroll_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english --preinclude=..\User\test_preinclude.h
  c include: ..\User;..\..\..\Host\Drivers;..\..\..\Host\Drivers\CMSIS\Include;..\..\..\Host\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Host\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Host\Drivers\SYSTEM\sys;..\..\..\Host\Drivers\SYSTEM\delay;..\..\..\Host\Drivers\SYSTEM\usart;..\..\..\Host\Drivers\BSP\AS608;..\..\..\Host\Drivers\BSP\LCD;..\..\..\Host\Drivers\BSP\TOUCH;..\..\..\Host\Drivers\BSP\mfrc522;..\..\..\Host\Drivers\BSP\24CXX;..\..\..\Host\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../Host/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Test/User
    ../User/: test_main.c test_usb_uart.c test_fp.c test_fp_uart.c test_hw_all.c test_w25q.c test_nfc.c test_hw_ui.c test_touch_diag.c test_wifi.c test_rs485_log.c test_stubs.c bsp_w25q16.c stm32f4xx_it.c
    ../../../Host/Drivers/BSP/AS608/: as608.c
    ../../../Host/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../Host/User/: stm32f4xx_hal_conf.h
  group Drivers/SYSTEM
    ../../../Host/Drivers/SYSTEM/sys/: sys.c
    ../../../Host/Drivers/SYSTEM/delay/: delay.c
  group Drivers/HAL
    ../../../Host/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c
  group Drivers/BSP
    ../../../Host/Drivers/BSP/LCD/: lcd.c
    ../../../Host/Drivers/BSP/TOUCH/: ft5206.c ctiic.c touch.c
    ../../../Host/Drivers/BSP/mfrc522/: MFRC522.c door.c
    ../../../Host/User/: app_nfc_hw.c
