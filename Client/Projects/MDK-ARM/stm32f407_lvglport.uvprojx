# Keil uVision project stm32f407_lvglport.uvprojx, settings and files
target stm32f407vet6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS-Kernel\include;..\..\Middlewares\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;..\..\User;..\..\Drivers\BSP;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\W25Q16;..\..\Drivers\SYSTEM\sys;..\..\Middlewares\LVGL\LVGL_SRC;..\..\Middlewares\LVGL\LVGL_SRC\lvgl;..\..\Middlewares\LVGL\LVGL_SRC\lvgl\src;..\..\Middlewares\LVGL\LVGL_SRC\lvgl\examples\porting;..\..\guider\custom;..\..\guider\generated;..\..\guider\generated\guider_customer_fonts;..\..\guider\generated\guider_fonts;..\..\guider\generated\images;..\..\Middlewares\LVGL\LVGL_SRC\lvgl\src\widgets;..\..\Drivers\BSP\mfrc522
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c cloud_ota_service.c cloud_legacy_adapter.c ota_control_port.c ui.c ui_auth_input.c ui_common_utils.c ui_flow_panels.c ui_menu_popup_utils.c ui_nav_flow.c ui_screen8_utils.c user_auth_portable.c app_user_ops.c app_key_ui.c app_touch_ui.c app_slave_host_time.c app_slave_unlock_queue.c app_state.c app_home_nav_btns.c app_board_gpio.c app_home_fp_poll.c app_home_unlock.c app_unlock_uart4.c app_rs485_link.c app_rs485_proto.c app_slave_fp_sync.c app_fp_hw_diag.c app_slave_ui_fixup.c app_unlock_event.c app_nav_entries.c app_nfc_hw.c app_screen_auth.c app_screen1_unlock.c app_screen2_login.c app_screen3_menu.c app_screen4_table.c app_screen5_flow.c app_screen6_commit.c app_screen6_dialog_base.c app_screen6_dialog_flow.c app_screen6_info.c app_screen7_flow.c app_screen8_enroll.c app_screen8_flow.c app_screen8_focus.c app_screen8_popup.c app_screen9_10_flow.c cloud_aliyun_at.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Mid/FreeRTOS
    ../../Middlewares/FreeRTOS-Kernel/: tasks.c list.c
    ../../Middlewares/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c lcdfont.h lcd.h
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/mfrc522/: door.c MFRC522.c
    ../../Drivers/BSP/AS608/: as608.c as608.h
    ../../Drivers/BSP/W25Q16/: bsp_w25q16.c
  group Readme
    ../../: readme.txt
  group Mid/lvgl/conf
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/: lv_conf.h lvgl.h
  group Mid/lvgl/example/porting
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Mid/lvgl/src/core
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Mid/lvgl/src/draw
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Mid/lvgl/src/extra
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/msg/: lv_msg.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/extra/: lv_extra.c
  group Mid/lvgl/src/font
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Mid/lvgl/src/hal
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Mid/lvgl/src/misc
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Mid/lvgl/src/widgets
    ../../Middlewares/LVGL/LVGL_SRC/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c lv_dclock.c
  group guider
    ../../guider/custom/: custom.c
    ../../guider/generated/: events_init.c gui_guider.c setup_scr_screen.c widgets_init.c lv_analogclock.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c setup_scr_screen_4.c setup_scr_screen_5.c setup_scr_screen_6.c setup_scr_screen_7.c setup_scr_screen_8.c setup_scr_screen_9.c
    ../../guider/generated/guider_fonts/: lv_font_montserratMedium_19.c lv_font_montserratMedium_51.c lv_font_SourceHanSerifSC_Regular_20.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c lv_font_montserratMedium_21.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_15.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_17.c lv_font_SourceHanSerifSC_Regular_18.c lv_font_SourceHanSerifSC_Regular_19.c lv_font_SourceHanSerifSC_Regular_21.c lv_font_SourceHanSerifSC_Regular_25.c
    ../../guider/generated/images/: _2_alpha_82x77.c _3_alpha_240x320.c
